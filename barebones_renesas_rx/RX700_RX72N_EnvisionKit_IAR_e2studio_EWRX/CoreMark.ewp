# IAR project CoreMark.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F572NN R5F572NN
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0
  General.IStackSize: 0x1000
  General.HeapSize: 0
  ICCRX.CCDefines: __RX; DISABLE_DEBUG_CONSOLE
  ICCRX.CCDiagSuppress: Pa091,Pe177
  ICCRX.CCIncludePath2: ..; ..\..; src; src\smc_workaround; src\smc_workaround\r_bsp_patch; src\smc_gen\Config_MTU1; src\smc_gen\Config_MTU2; src\smc_gen\Config_SCI2; src\smc_gen\general; src\smc_gen\r_bsp; src\smc_gen\r_config; src\smc_gen\r_pincfg
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\; src
  OBJCOPY.OOCOutputFile: CoreMark.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  General.OGChipSelectMenu: RX600 Generic RX600
  General.StackSize: 0x100
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: NDEBUG
  ICCRX.CCIncludePath2: C:\Renesas\GitHubDesktop\work\CoreMark\barebones-renesas-rx\RX700_RX72N_EnvisionKit_IAR_e2studio_EWRX\src\smc_gen\Config_MTU1; C:\Renesas\GitHubDesktop\work\CoreMark\barebones-renesas-rx\RX700_RX72N_EnvisionKit_IAR_e2studio_EWRX\src\smc_gen\Config_MTU2; C:\Renesas\GitHubDesktop\work\CoreMark\barebones-renesas-rx\RX700_RX72N_EnvisionKit_IAR_e2studio_EWRX\src\smc_gen\Config_SCI2; C:\Renesas\GitHubDesktop\work\CoreMark\barebones-renesas-rx\RX700_RX72N_EnvisionKit_IAR_e2studio_EWRX\src\smc_gen\general; C:\Renesas\GitHubDesktop\work\CoreMark\barebones-renesas-rx\RX700_RX72N_EnvisionKit_IAR_e2studio_EWRX\src\smc_gen\r_bsp; C:\Renesas\GitHubDesktop\work\CoreMark\barebones-renesas-rx\RX700_RX72N_EnvisionKit_IAR_e2studio_EWRX\src\smc_gen\r_config; C:\Renesas\GitHubDesktop\work\CoreMark\barebones-renesas-rx\RX700_RX72N_EnvisionKit_IAR_e2studio_EWRX\src\smc_gen\r_pincfg
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  group Renesas_AP
    ./: SmartConfigurator.ipcf
  group Renesas_AP/smc_gen/Config_MTU1
    src/smc_gen/Config_MTU1/: Config_MTU1.c Config_MTU1.h Config_MTU1_user.c
  group Renesas_AP/smc_gen/Config_MTU2
    src/smc_gen/Config_MTU2/: Config_MTU2.c Config_MTU2.h Config_MTU2_user.c
  group Renesas_AP/smc_gen/Config_SCI2
    src/smc_gen/Config_SCI2/: Config_SCI2.c Config_SCI2.h Config_SCI2_user.c
  group Renesas_AP/smc_gen/general
    src/smc_gen/general/: r_cg_hardware_setup.c r_cg_macrodriver.h r_cg_mtu3.h r_cg_sci.h r_cg_tpu.h r_cg_userdefine.h r_smc_cgc.c r_smc_cgc.h r_smc_cgc_user.c r_smc_entry.h r_smc_interrupt.c r_smc_interrupt.h
  group Renesas_AP/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group Renesas_AP/smc_gen/r_bsp/board/generic_rx72n
    src/smc_gen/r_bsp/board/generic_rx72n/: hwsetup.c hwsetup.h r_bsp.h r_bsp_config_reference.h r_bsp_interrupt_config_reference.h
  group Renesas_AP/smc_gen/r_bsp/board/user
    src/smc_gen/r_bsp/board/user/: r_bsp.h
  group Renesas_AP/smc_gen/r_bsp/doc/en
    src/smc_gen/r_bsp/doc/en/: r01an1685ej0561-rx-bsp.pdf
  group Renesas_AP/smc_gen/r_bsp/doc/ja
    src/smc_gen/r_bsp/doc/ja/: r01an1685jj0561-rx-bsp.pdf
  group Renesas_AP/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: lowlvl.h lowsrc.h mcu_locks.c r_bsp_common.c r_bsp_common.h r_bsp_cpu.c r_bsp_interrupts.c r_bsp_interrupts.h r_bsp_locking.c r_bsp_mcu_startup.c r_bsp_mcu_startup.h r_bsp_software_interrupt.c r_bsp_software_interrupt.h r_rtos.h r_rx_compiler.h r_rx_intrinsic_functions.c r_rx_intrinsic_functions.h r_typedefs.h resetprg.c
  group Renesas_AP/smc_gen/r_bsp/mcu/rx72n
    src/smc_gen/r_bsp/mcu/rx72n/: mcu_clocks.c mcu_clocks.h mcu_info.h mcu_init.c mcu_init.h mcu_interrupts.c mcu_interrupts.h mcu_locks.h mcu_mapped_interrupts.c mcu_mapped_interrupts.h mcu_mapped_interrupts_private.h r_bsp_cpu.h r_bsp_locking.h vecttbl.c vecttbl.h
  group Renesas_AP/smc_gen/r_bsp/mcu/rx72n/register_access/iccrx
    src/smc_gen/r_bsp/mcu/rx72n/register_access/iccrx/: iodefine.h
  group Renesas_AP/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h r_bsp_config_readme.txt r_bsp_interrupt_config.h
  group Renesas_AP/smc_gen/r_pincfg
    src/smc_gen/r_pincfg/: Pin.c Pin.h
  group Renesas_AP_tips/smc_workaround
    src/smc_workaround/: CC_patch.h CG_patch.h Config_ext.h FIT_patch.c FIT_patch.h FIT_patch2.h IDE_patch.h smc_workaround.h
  group Renesas_AP_tips/smc_workaround/r_bsp_patch
    src/smc_workaround/r_bsp_patch/: lowlvl.c platform.h
  group Src
    ../: portme_config.h
    src/: portme_helper.c portme_helper.h
  group Src/coremark
    ../../: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c coremark.h
  group Src/coremark/barebones_renesas_rx
    ../: core_portme.c core_portme.h ee_printf.c
    ../../barebones/: cvt.c
